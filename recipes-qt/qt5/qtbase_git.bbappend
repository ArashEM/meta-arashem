PACKAGECONFIG += " fontconfig"
PACKAGECONFIG_remove = " tests"

